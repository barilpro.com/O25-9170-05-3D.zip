Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\Thomas.Vidal.Soler\Baril Manufacturier Inc\PRODUIT - Suivi projets R-D\01_PROJETS\80_MARKETING\DOCUMENTATION COMMERCIALE\CAD_2D-3D\01_BARIL PRO\fichiers non zippés\3d\IFC\O25-9170-x5_3D.IFC
Time: 2025-07-15T18:16:12+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
